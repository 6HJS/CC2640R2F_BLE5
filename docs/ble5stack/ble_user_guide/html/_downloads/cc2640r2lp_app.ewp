# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; EXT_HAL_ASSERT; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=4; POWER_SAVING; STACK_LIBRARY; TBM_ACTIVE_ITEMS_ONLY; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$/config/build_components.opt; -f ..\stack\build_config.opt; -f $SRC_BLE_DIR$/config/factory_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$/controller/cc26xx_r2/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/common/cc26xx; $SRC_BLE_DIR$/common/cc26xx/menu; ..\..\..\src/app; $SRC_BLE_DIR$/icall/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/profiles/dev_info; $SRC_BLE_DIR$/profiles/roles; $SRC_BLE_DIR$/profiles/roles/cc26xx; $SRC_BLE_DIR$/profiles/simple_profile; $SRC_BLE_DIR$/profiles/simple_profile/cc26xx; $SRC_BLE_DIR$/target; $SRC_COMMON_DIR$/hal/src/inc; $SRC_COMMON_DIR$/hal/src/target/_common; $SRC_COMMON_DIR$/hal/src/target/_common/cc26xx; $SRC_COMMON_DIR$/hal/src/target/cc2650/rom; $SRC_COMMON_DIR$/heapmgr; $SRC_COMMON_DIR$/icall/src/inc; $SRC_COMMON_DIR$/osal/src/inc; $SRC_COMMON_DIR$/services/src/saddr; $SRC_COMMON_DIR$/services/src/sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multi_role_cc2640r2lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  ILINK.IlinkOutputFile: multi_role_cc2640r2lp_app.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_StackLibrary-CacheAsRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CACHE_AS_RAM; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; EXT_HAL_ASSERT; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=8; POWER_SAVING; STACK_LIBRARY; TBM_ACTIVE_ITEMS_ONLY; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$/controller/cc26xx_r2/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/common/cc26xx; $SRC_BLE_DIR$/common/cc26xx/menu; ..\..\..\src/app; $SRC_BLE_DIR$/icall/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/profiles/dev_info; $SRC_BLE_DIR$/profiles/roles; $SRC_BLE_DIR$/profiles/roles/cc26xx; $SRC_BLE_DIR$/profiles/simple_profile; $SRC_BLE_DIR$/profiles/simple_profile/cc26xx; $SRC_BLE_DIR$/target; $SRC_COMMON_DIR$/hal/src/inc; $SRC_COMMON_DIR$/hal/src/target/_common; $SRC_COMMON_DIR$/hal/src/target/_common/cc26xx; $SRC_COMMON_DIR$/hal/src/target/cc2650/rom; $SRC_COMMON_DIR$/heapmgr; $SRC_COMMON_DIR$/icall/src/inc; $SRC_COMMON_DIR$/osal/src/inc; $SRC_COMMON_DIR$/services/src/saddr; $SRC_COMMON_DIR$/services/src/sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc26x0r2RE$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2; CACHE_AS_RAM=1
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl; -f ../config/lib_linker.cmd
  group Application
    $SRC_BLE_DIR$/common/cc26xx/: board_key.c board_key.h util.c util.h
    $SRC_COMMON_DIR$/hal/src/common/: hal_assert.c
    ../../../src/app/: multi_role.c multi_role.h multi_role_menu.c multi_role_menu.h
    $SRC_BLE_DIR$/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
  group Drivers
    $SRC_COMMON_DIR$/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    $SRC_BLE_DIR$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_COMMON_DIR$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_COMMON_DIR$/heapmgr/: heapmgr.h
    $SRC_COMMON_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_COMMON_DIR$/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_DIR$/inc/: gap.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/profiles/roles/: gapbondmgr.h
    $SRC_COMMON_DIR$/osal/src/inc/: osal_snv.h
  group Profiles
    $SRC_BLE_DIR$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_BLE_DIR$/profiles/dev_info/: devinfoservice.h
    $SRC_BLE_DIR$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SRC_BLE_DIR$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_DIR$/profiles/roles/cc26xx/: multi.c multi.h
    $SRC_BLE_DIR$/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $SRC_BLE_DIR$/profiles/simple_profile/: simple_gatt_profile.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE_DIR$/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app_and_stack.icf
