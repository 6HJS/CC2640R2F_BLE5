<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\rtos_create.ewp</path>
    </project>
    <batchBuild />
</workspace>
