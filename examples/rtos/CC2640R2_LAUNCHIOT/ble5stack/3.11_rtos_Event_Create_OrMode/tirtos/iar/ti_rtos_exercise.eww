<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\rtos_event_create_or.ewp</path>
    </project>
    <batchBuild />
</workspace>
