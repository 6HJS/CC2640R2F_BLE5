# IAR project rtos_hwi_critical.ewp, settings and files
configuration Display_tft (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=1; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; CC2640R2MOD_RGZ; CC26XX; CC26XX_R2; FLASH_ROM_BUILD; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; xICALL_EVENTS; xICALL_JT; xICALL_LITE; xICALL_MAX_NUM_ENTITIES=6; xICALL_MAX_NUM_TASKS=3; xICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; RF_SINGLEMODE; xSTACK_LIBRARY; TBM_ACTIVE_ITEMS_ONLY; xUSE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; IOTXX_DISPLAY_TFT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -Dxdc_target_types__=iar\targets\arm\std.h
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; ..\..\..\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx\npi\stack; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SRC_BLE_DIR$\services\src\saddr; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $XDCROOT$\packages; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\src\driver\pwm; $EXAMPLE_BLE_ROOT$\..\target; $EXAMPLE_BLE_ROOT$\..\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\..\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\gpio; $EXAMPLE_BLE_ROOT$\..\common\display
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Display_ePaper (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=1; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; CC2640R2MOD_RGZ; CC26XX; CC26XX_R2; FLASH_ROM_BUILD; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; xICALL_EVENTS; xICALL_JT; xICALL_LITE; xICALL_MAX_NUM_ENTITIES=6; xICALL_MAX_NUM_TASKS=3; xICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; RF_SINGLEMODE; xSTACK_LIBRARY; TBM_ACTIVE_ITEMS_ONLY; xUSE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; IOTXX_DISPLAY_EPD
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; ..\..\..\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx\npi\stack; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SRC_BLE_DIR$\services\src\saddr; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $XDCROOT$\packages; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\..\target; $EXAMPLE_BLE_ROOT$\..\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\..\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\gpio; $EXAMPLE_BLE_ROOT$\..\common\display
  group Drivers/KEY
    ../../../src/app/: board_key.c board_key.h ClockUtil.c ClockUtil.h
  group Drivers/PWM
    ../../../src/driver/pwm/: hw_pwm.c hw_pwm.h
  group GY_Serial
    ../../../src/driver/gpio/: hw_gpio.c hw_gpio.h
  group GY_Serial/Display
    ../../../../common/display/: DisplayEPD200.h DisplayTFT128.h EPD200.h lcd_epd_lib_r2.a lcd_tft_lib_r2.a TFT128.h
  group ICall
    ../../../../../../../../source/ti/ble5stack/icall/src/: icall.c
    ../../../../../../../../source/ti/ble5stack/icall/src/inc/: icall.h
  group Middleware/ExtFlash
    ../../../../../../../../source/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Startup
    ../../../../target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_and_stack.icf cc26xx_app_oad.icf
