# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2MOD_RGZ; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; FEATURE_ADVERTISER; FEATURE_BROADCASTER; xFEATURE_STATIC_ADDR; ICALL_EVENTS; POWER_SAVING; RF_SINGLEMODE; xUSE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $XDCROOT$\packages; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $EXAMPLE_BLE_ROOT$\..\target; $EXAMPLE_BLE_ROOT$\..\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\..\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\gpio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble5_micro_eddystone_beacon_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app.icf
  ILINK.IlinkExtraOptions: -f ..\config\configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_MultiMode (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; FEATURE_ADVERTISER; FEATURE_BROADCASTER; xFEATURE_STATIC_ADDR; ICALL_EVENTS; POWER_SAVING; RF_MULTIMODE; xUSE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $XDCROOT$\packages; $SRC_BLE_DIR$\boards; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_multiMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  group Application
    ../../../../target/: iotboard_key.c iotboard_key.h
    ../../../src/app/: micro_eddystone_beacon.c micro_eddystone_beacon.h
  group GY_Serial
    ../../../src/driver/gpio/: hw_gpio.c hw_gpio.h
  group HAL/Common
    ../../../../../../../../source/ti/ble5stack/hal/src/common/: hal_assert.c
  group HAL/Include
    ../../../../../../../../source/ti/ble5stack/hal/src/inc/: hal_assert.h
  group ICall
    ../../../../../../../../source/ti/ble5stack/icall/src/: icall.c icall_cc2650.c
    ../../../../../../../../source/ti/ble5stack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/: util.c util.h
  group Stack
    ../../../../../../../../source/ti/ble5stack/microstack/: uble.c ugap.c ull.c urfi.c
    ../../../../../../../../source/ti/ble5stack/inc/: uble.h ugap.h ull.h urfi.h
  group Startup
    ../../../../target/: board.c urfc.c urfc.h
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/iar/: cc26xx_app.icf
