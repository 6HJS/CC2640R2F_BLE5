<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\rtos_preempt.ewp</path>
    </project>
    <batchBuild />
</workspace>
