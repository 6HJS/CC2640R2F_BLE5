# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=1; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; _CC2640R2MOD_RGZ; CC2640R2MOD_RSM; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; TBM_ACTIVE_ITEMS_ONLY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; PROFILE_Multibyte; IOTXX_DISPLAY_TFT; MAX_PDU_SIZE=27; xGAPROLE_TASK_STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $EXAMPLE_BLE_ROOT$\src\target; $EXAMPLE_BLE_ROOT$\src\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\src\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\uart; $EXAMPLE_BLE_ROOT$\src\driver\i2c; $EXAMPLE_BLE_ROOT$\src\driver\bma250e; $EXAMPLE_BLE_ROOT$\src\driver\pwm; $EXAMPLE_BLE_ROOT$\src\driver\adc; $EXAMPLE_BLE_ROOT$\src\driver\gpio; $EXAMPLE_BLE_ROOT$\src\profile; $EXAMPLE_BLE_ROOT$\..\common\display; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\target\LAUNCHIOT_CC2640R2MOD_RSM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble5_simple_peripheral_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_StackLibrary_ePaper (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=1; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; CC2640R2MOD_RGZ; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; TBM_ACTIVE_ITEMS_ONLY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; PROFILE_Multibyte; IOTXX_DISPLAY_EPD
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $EXAMPLE_BLE_ROOT$\src\target; $EXAMPLE_BLE_ROOT$\src\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\src\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\uart; $EXAMPLE_BLE_ROOT$\src\driver\i2c; $EXAMPLE_BLE_ROOT$\src\driver\bma250e; $EXAMPLE_BLE_ROOT$\src\driver\pwm; $EXAMPLE_BLE_ROOT$\src\driver\adc; $EXAMPLE_BLE_ROOT$\src\driver\gpio; $EXAMPLE_BLE_ROOT$\src\profile; $EXAMPLE_BLE_ROOT$\..\common\display
  group Application
    ../../../src/target/: iotboard_key.c iotboard_key.h
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    ../../../src/app/: simple_peripheral.c simple_peripheral.h simple_peripheral_menu.c simple_peripheral_menu.h
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/: util.c util.h
  group Drivers
    ../../../../../../../../source/ti/ble5stack/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../../../../../../source/ti/ble5stack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group GY_Serial
    ../../../../common/display/: DisplayEPD200.h DisplayTFT128.h EPD200.h lcd_epd_lib_r2.a lcd_tft_lib_r2.a TFT128.h
    ../../../src/driver/adc/: hw_adc.c hw_adc.h
    ../../../src/driver/bma250e/: hw_bma250e.c hw_bma250e.h hw_bma250e_Spec.h
    ../../../src/driver/gpio/: hw_gpio.c hw_gpio.h
    ../../../src/driver/i2c/: hw_i2c.c hw_i2c.h
    ../../../src/driver/pwm/: hw_pwm.c hw_pwm.h
    ../../../src/driver/uart/: task_uart.c task_uart.h
  group ICall
    ../../../../../../../../source/ti/ble5stack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/ble5stack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/ble5stack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../../../../source/ti/ble5stack/icall/app/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/ble5stack/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    ../../../../../../../../source/ti/ble5stack/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/ble5stack/profiles/roles/: gapbondmgr.h
    ../../../../../../../../source/ti/ble5stack/osal/src/inc/: osal_snv.h
  group Middleware/ExtFlash
    ../../../../../../../../source/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Profiles
    ../../../../../../../../source/ti/ble5stack/profiles/dev_info/cc26xx/: devinfoservice.c
    ../../../../../../../../source/ti/ble5stack/profiles/dev_info/: devinfoservice.h
    ../../../../../../../../source/ti/ble5stack/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../../../../source/ti/ble5stack/host/: gatt_uuid.c gattservapp_util.c
    ../../../../../../../../source/ti/ble5stack/profiles/oad/cc26xx/: oad.c oad.h oad_reset_service.c oad_target.h oad_target_external_flash.c oad_target_internal_flash.c
    ../../../../../../../../source/ti/ble5stack/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../../src/profile/: simple_gatt_profile.c simple_gatt_profile.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    ../../../src/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_and_stack.icf cc26xx_app_oad.icf
