<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\rtos_sema_count.ewp</path>
    </project>
    <batchBuild />
</workspace>
