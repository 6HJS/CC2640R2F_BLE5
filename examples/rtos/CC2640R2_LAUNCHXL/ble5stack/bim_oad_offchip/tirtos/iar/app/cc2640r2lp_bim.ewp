# IAR project cc2640r2lp_bim.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOOT_LOADER; xNO_COPY; RF_SINGLEMODE; ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $XDCROOT$\packages; $EXAMPLE_BLE_ROOT$\src\board; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\osal\src\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  ILINK.IlinkOutputFile: ble5_bim_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_bim_r2.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $EXAMPLE_BLE_ROOT$/src/: bim_main.c bls.h bls_bsp.c ccfg_app_ble.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc26x0r2/startup_files/: startup_iar.c
  group Board
    $EXAMPLE_BLE_ROOT$/src/board/: bsp.h
  group Ext Flash
    $EXAMPLE_BLE_ROOT$/src/board/: ext_flash.c ext_flash.h
  group SPI
    $EXAMPLE_BLE_ROOT$/src/board/: bsp_spi.c bsp_spi.h
  group TOOLS
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_bim_r2.icf
