# IAR project cc2640r2lp_stack.ewp, settings and files
configuration FlashROM_Library (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC26XX; CC26XX_R2; xDEBUG; xDEBUG_ENC; xDEBUG_GPIO; xDEBUG_SW_TRACE; DeviceFamily_CC26X0R2; ENABLE_ROM_CHECKSUM_CHECK; EXT_HAL_ASSERT; FLASH_ROM_BUILD; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_LITE_12_PARAMS; OSAL_CBTIMER_NUM_TASKS=1; OSAL_SNV=2; POWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; xTESTMODES; USE_ICALL
  ICCARM.IExtraOptions: --aeabi; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; --diag_suppress=Pa050; -Dxdc_target_types__=iar\targets\arm\std.h; --make_all_definitions_weak
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\npi\stack; $SRC_BLE_DIR$\hal\src\target\_common; $EXAMPLE_BLE_ROOT$\src\stack; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\aes\cc26xx; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SRC_BLE_DIR$\services\src\saddr; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $XDCROOT$\packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: $TOOLS_BLE_DIR$\lib_search\lib_search.exe $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt $SRC_BLE_DIR$\blelib ..\config\lib_linker.cmd cc2640 $TOOLS_BLE_DIR$\lib_search\lib_search.xml $SRC_BLE_DIR$\symbols
  ILINK.IlinkOutputFile: ble_host_test_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=2; CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_stack.icf
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/API
    $SRC_BLE_DIR$/hal/src/target/_common/: crypto_api.h ecc_api.h rf_api.h rtos_drivers.h trng_api.h
  group HAL/Common
    $SRC_BLE_DIR$/hal/src/common/: hal_assert.c
  group HAL/Include
    $SRC_BLE_DIR$/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_mcu.h
    $SRC_BLE_DIR$/hal/src/target/_common/cc26xx/: mb.h rf_hal.h
    $SRC_BLE_DIR$/rom/r1/: r2f_common_flash_jt.h r2r_common_flash_jt.h
  group HAL/Target/CC2650/Config
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group Host
    $SRC_BLE_DIR$/inc/: gatt_internal.h gatt_uuid.h
    $SRC_BLE_DIR$/host/: gatt_uuid.c
  group ICallBLE
    $SRC_BLE_DIR$/icall/inc/: ble_dispatch.h
    $SRC_BLE_DIR$/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    $SRC_BLE_DIR$/icall/src/: icall_lite_translation.c
  group NPI
    $SRC_BLE_DIR$/common/cc26xx/npi/stack/: npi.c npi.h
    $SRC_BLE_DIR$/npi/src/inc/: npi_ble.h
  group OSAL
    $SRC_BLE_DIR$/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SRC_BLE_DIR$/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SRC_BLE_DIR$/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group Profiles
    $SRC_BLE_DIR$/profiles/roles/: gap.c gapbondmgr.c gapbondmgr.h
    $SRC_BLE_DIR$/inc/: gapgattserver.h gattservapp.h
    $SRC_BLE_DIR$/host/: gattservapp_util.c sm_ecc.c
  group ROM
    $SRC_BLE_DIR$/rom/r2/: common_rom_init.c rom_flash_jt.h rom_init.c
  group Startup
    $SRC_BLE_DIR$/icall/stack/: ble_user_config.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_addrs.h
    $SRC_BLE_DIR$/common/cc26xx/: icall_startup.c
    $EXAMPLE_BLE_ROOT$/src/stack/: osal_icall_ble.c
  group Tools
    $SRC_BLE_DIR$/config/: build_components.opt
    $EXAMPLE_BLE_ROOT$/tirtos/: build_config.opt
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_stack.icf
    $SRC_BLE_DIR$/common/cc26xx/: onboard.c onboard.h
