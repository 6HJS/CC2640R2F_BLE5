# IAR project cc2640r2lp_persistent_app.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; EXT_HAL_ASSERT; HAL_IMAGE_A; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; LED_DEBUG; MAX_NUM_BLE_CONNS=1; MAX_PDU_SIZE=251; xOAD_BLE_SECURITY; OAD_ONCHIP; POWER_SAVING; RF_SINGLEMODE; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\persistent_app\configPkg\compiler.opt.defs; -f ..\config\iar_oad_tgt_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\flash_interface; $SRC_BLE_DIR$\common\cc26xx\crc; $SRC_BLE_DIR$\common\cc26xx\bim; $EXAMPLE_BLE_ROOT$\src\persistent_app; $EXAMPLE_BLE_ROOT$\src; $EXAMPLE_BLE_ROOT$\..\bim_oad_offchip\src\board; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs "{NO_ROM:1, OAD_IMG_A:1}" -o "..\config\persistent_app\configPkg" $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg"
  postbuild: cmd /C "$TOOLS_BLE_DIR$\frontier\frontier.exe iar -b 1 $CONFIG_NAME$\List\sp_oad_onchip_cc2640r2lp_persistent_app_FlashOnly.map ..\config\iar_oad_tgt_boundary.bdef ..\config\iar_oad_tgt_boundary.xcl & $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.bin -b ..\config\iar_oad_tgt_boundary.bdef"
  ILINK.IlinkOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; RTOS_ROM=0; ICALL_RAM0_START=0x20003A00
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\persistent_app\configPkg\linker.cmd; -f ..\config\iar_oad_tgt_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM_DIR$\ble_rom_releases\cc26xx_r2\Final_Release\common_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SRC_BLE_DIR$/common/cc26xx/bim/: bim_util.c bim_util.h
    $SRC_BLE_DIR$/hal/src/common/: hal_assert.c
    $EXAMPLE_BLE_ROOT$/src/persistent_app/: oad_persistent_app.c oad_persistent_app.h
    $SRC_BLE_DIR$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $SRC_BLE_DIR$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_BLE_DIR$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_BLE_DIR$/heapmgr/: heapmgr.h
    $SRC_BLE_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_DIR$/inc/: gap.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/profiles/roles/: gapbondmgr.h
    $SRC_BLE_DIR$/osal/src/inc/: osal_snv.h
  group OAD
    $SRC_BLE_DIR$/common/cc26xx/crc/: crc32.c crc32.h
    $SRC_BLE_DIR$/common/cc26xx/flash_interface/: flash_interface.h
    $SRC_BLE_DIR$/common/cc26xx/flash_interface/internal/: flash_interface_internal.c
    $SRC_BLE_DIR$/profiles/oad/cc26xx/: oad.c oad.h oad_image_header.h oad_image_header_app.c
  group Profiles
    $SRC_BLE_DIR$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SRC_BLE_DIR$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_DIR$/profiles/roles/cc26xx/: peripheral.c peripheral.h
  group Startup
    $SRC_BLE_DIR$/target/: board.c
    $SRC_BLE_DIR$/profiles/oad/cc26xx/: find_stack_entry.c find_stack_entry.h
    $EXAMPLE_BLE_ROOT$/src/persistent_app/: main.c
  group Tools
    $EXAMPLE_BLE_ROOT$/tirtos/: app_ble.cfg
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app_oad.icf
