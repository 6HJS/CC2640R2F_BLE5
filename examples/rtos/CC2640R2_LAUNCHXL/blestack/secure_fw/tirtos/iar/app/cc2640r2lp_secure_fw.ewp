# IAR project cc2640r2lp_secure_fw.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\sha2\; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\osal\src\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin -a 0x0001F000
  ILINK.IlinkOutputFile: cc2640r2lp_secure_firmware.out
  ILINK.IlinkConfigDefines: CC2650=2; RTOS_IN_ROM=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_secure_fw.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $ROM_DIR$\ble_rom_releases\cc26xx_r2\Final_Release\ble_r2.symbols; $SRC_BLE_DIR$\common\cc26xx\sha2\SHA2CC26XX.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    $EXAMPLE_BLE_ROOT$/src/: secure_fw_config.h startup_iar.c
  group Application
    $EXAMPLE_BLE_ROOT$/src/: secure_fw.c secure_fw.h secure_fw_main.c ccfg_app_ble.c
    $SRC_BLE_DIR$/common/cc26xx/sha2/: SHA2CC26XX.h
  group TOOLS
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_secure_fw.icf
